# Keil uVision project MKL62BA_test.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x00800000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: MKL62BA_TEST +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52832_XXAA NRF_SD_BLE_API_VERSION=7 CONFIG_NFCT_PINS_AS_GPIOS REGION_AS923 REGION_AU915  REGION_CN470 REGION_CN779 REGION_EU433  REGION_EU868 REGION_KR920  REGION_IN865 REGION_US915 REGION_RU864
  c misc: --reduce_paths
  c include: .\config;..\components;..\components\ble\ble_dtm;..\components\ble\ble_link_ctx_manager;..\components\ble\ble_racp;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\libraries\atomic;..\components\libraries\atomic_fifo;..\components\libraries\atomic_flags;..\components\libraries\balloc;..\components\libraries\cli;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\crypto;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\delay;..\components\libraries\ecc;..\components\libraries\experimental_section_vars;..\components\libraries\experimental_task_manager;..\components\libraries\fifo;..\components\libraries\fstorage;..\components\libraries\gfx;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\memobj;..\components\libraries\mpu;..\components\libraries\mutex;..\components\libraries\pwm;..\components\libraries\pwr_mgmt;..\components\libraries\queue;..\components\libraries\ringbuf;..\components\libraries\scheduler;..\components\libraries\sdcard;..\components\libraries\slip;..\components\libraries\sortlist;..\components\libraries\spi_mngr;..\components\libraries\stack_guard;..\components\libraries\strerror;..\components\libraries\svc;..\components\libraries\timer;..\components\libraries\twi_mngr;..\components\libraries\twi_sensor;..\components\libraries\uart;..\components\libraries\util;..\components\nfc\ndef\conn_hand_parser;..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\components\nfc\ndef\connection_handover\ac_rec;..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\components\nfc\ndef\connection_handover\ble_pair_lib;..\components\nfc\ndef\connection_handover\ble_pair_msg;..\components\nfc\ndef\connection_handover\common;..\components\nfc\ndef\connection_handover\ep_oob_rec;..\components\nfc\ndef\connection_handover\hs_rec;..\components\nfc\ndef\connection_handover\le_oob_rec;..\components\nfc\ndef\generic\message;..\components\nfc\ndef\generic\record;..\components\nfc\ndef\launchapp;..\components\nfc\ndef\parser\message;..\components\nfc\ndef\parser\record;..\components\nfc\ndef\text;..\components\nfc\ndef\uri;..\components\nfc\platform;..\components\nfc\t2t_lib;..\components\nfc\t2t_parser;..\components\nfc\t4t_lib;..\components\nfc\t4t_parser\apdu;..\components\nfc\t4t_parser\cc_file;..\components\nfc\t4t_parser\hl_detection_procedure;..\components\nfc\t4t_parser\tlv;..\external\utf_converter;..\integration\nrfx;..\integration\nrfx\legacy;..\modules\nrfx;..\modules\nrfx\drivers\include;..\modules\nrfx\hal;..\config;..\src;..\src\segger_rtt;..\components\ble\ble_services\ble_dis;..\components\ble\ble_advertising;..\src\soft_lib;..\src\sys;..\src\system_port;..\src\lorawan_sdk\boards;..\src\lorawan_sdk\boards\52832;..\src\lorawan_sdk\mac;..\src\lorawan_sdk\mac\region;..\src\lorawan_sdk\peripherals\soft-se;..\src\lorawan_sdk\radio;..\src\lorawan_sdk\radio\sx126x;..\src\lorawan_sdk\system;..\components\libraries\util;..\components\softdevice\s132\headers;..\src\lorawan_sdk
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52833_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=71680 __STACK_SIZE=10240
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10100,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52833_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_link_ctx_manager;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\libraries\atomic;..\components\libraries\atomic_fifo;..\components\libraries\atomic_flags;..\components\libraries\balloc;..\components\libraries\bootloader\ble_dfu;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\cli;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\crypto;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\delay;..\components\libraries\ecc;..\components\libraries\experimental_section_vars;..\components\libraries\experimental_task_manager;..\components\libraries\fds;..\components\libraries\fifo;..\components\libraries\fstorage;..\components\libraries\gfx;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\memobj;..\components\libraries\mpu;..\components\libraries\mutex;..\components\libraries\pwm;..\components\libraries\pwr_mgmt;..\components\libraries\queue;..\components\libraries\ringbuf;..\components\libraries\scheduler;..\components\libraries\sdcard;..\components\libraries\slip;..\components\libraries\sortlist;..\components\libraries\spi_mngr;..\components\libraries\stack_guard;..\components\libraries\strerror;..\components\libraries\svc;..\components\libraries\timer;..\components\libraries\twi_mngr;..\components\libraries\twi_sensor;..\components\libraries\uart;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\util;..\components\nfc\ndef\conn_hand_parser;..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\components\nfc\ndef\connection_handover\ac_rec;..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\components\nfc\ndef\connection_handover\ble_pair_lib;..\components\nfc\ndef\connection_handover\ble_pair_msg;..\components\nfc\ndef\connection_handover\common;..\components\nfc\ndef\connection_handover\ep_oob_rec;..\components\nfc\ndef\connection_handover\hs_rec;..\components\nfc\ndef\connection_handover\le_oob_rec;..\components\nfc\ndef\generic\message;..\components\nfc\ndef\generic\record;..\components\nfc\ndef\launchapp;..\components\nfc\ndef\parser\message;..\components\nfc\ndef\parser\record;..\components\nfc\ndef\text;..\components\nfc\ndef\uri;..\components\nfc\platform;..\components\nfc\t2t_lib;..\components\nfc\t2t_parser;..\components\nfc\t4t_lib;..\components\nfc\t4t_parser\apdu;..\components\nfc\t4t_parser\cc_file;..\components\nfc\t4t_parser\hl_detection_procedure;..\components\nfc\t4t_parser\tlv;..\components\softdevice\common;..\components\softdevice\s140\headers;..\components\softdevice\s140\headers\nrf52;..\external\fprintf;..\external\segger_rtt;..\external\utf_converter;..\integration\nrfx;..\integration\nrfx\legacy;..\modules\nrfx;..\modules\nrfx\drivers\include;..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x800000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ./: main.c
    ./config/: sdk_config.h
  group nRF_Drivers
    ../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_spi.c nrf_drv_twi.c nrf_drv_rng.c
    ../modules/nrfx/soc/: nrfx_atomic.c
    ../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_spim.c nrfx_saadc.c nrfx_twim.c nrfx_wdt.c nrfx_rng.c
    ../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../modules/nrfx/hal/: nrf_nvmc.c
  group nRF_Libraries
    ../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../components/libraries/hardfault/: hardfault_implementation.c
    ../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../components/libraries/atomic_flags/: nrf_atflags.c
    ../components/libraries/atomic/: nrf_atomic.c
    ../components/libraries/balloc/: nrf_balloc.c
    ../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../components/libraries/memobj/: nrf_memobj.c
    ../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../components/libraries/ringbuf/: nrf_ringbuf.c
    ../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../components/libraries/sortlist/: nrf_sortlist.c
    ../components/libraries/strerror/: nrf_strerror.c
    ../components/libraries/uart/: retarget.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/queue/: nrf_queue.c
  group RTT
    ../src/segger_rtt/: SEGGER_RTT_printf.c SEGGER_RTT.c
  group soft_lib
    ../src/soft_lib/: system_time.c
  group sys
    ../src/sys/: platform_driver.c wdt.c in_flash_manage.c
  group loramac_board
    ../src/lorawan_sdk/boards/52832/: board.c delay-board.c rtc-board.c spi-board.c sx1262mbxcas-board.c utilities.c
  group loramac_mac
    ../src/lorawan_sdk/mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    ../src/lorawan_sdk/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionRU864.c RegionUS915.c
  group loramac_peripherals
    ../src/lorawan_sdk/peripherals/soft-se/: aes.c cmac.c soft-se.c soft-se-hal.c
  group loramac_radio
    ../src/lorawan_sdk/radio/sx126x/: radio.c sx126x.c
  group loramac_system
    ../src/lorawan_sdk/system/: delay.c fifo.c systime.c timer.c
  group lorawan_app
    ../src/lorawan_sdk/: lorawan_app.c
target flash_s140_nrf52_7.0.1_softdevice (ARM-ADS)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: s140_nrf52_7.0.1_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=2048 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=2048 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0x59000
  memory RVCT9: RAM 0x20002ae8 size 0x1d518
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, Device:Startup 8.32.1
